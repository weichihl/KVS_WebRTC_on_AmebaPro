# IAR project application_lp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDefines: __thumb2__; CONFIG_PLATFORM_8195B; CONFIG_PLATFORM_8195BLP=1; __FPU_PRESENT; __ARM_ARCH_7M__=0; __ARM_ARCH_8M_MAIN__=0; __ARM_ARCH_8M_BASE__=1; CONFIG_BUILD_RAM=1; _NO_DEFINITIONS_IN_HEADER_FILES; CONFIG_DISABLE_LP_SHELL; CONFIG_SWWDT_EN=1; CONFIG_LS_RESET_REQ_EN=1
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\component\soc\realtek\8195b\cmsis\rtl8195b-lp\include; ..\..\..\component\soc\realtek\8195b\cmsis\cmsis-core\include; ..\..\..\component\soc\realtek\8195b\fwlib\hal-rtl8195b-lp\include; ..\..\..\component\soc\realtek\8195b\fwlib\hal-rtl8195b-lp\lib\include; ..\..\..\component\soc\realtek\8195b\app\rtl_printf\include; ..\..\..\component\soc\realtek\8195b\app\shell; ..\..\..\component\soc\realtek\8195b\app\stdio_port; ..\..\..\component\soc\realtek\8195b\misc\utilities\include; ..\..\..\component\common\api; ..\..\..\component\common\api\platform; ..\..\..\component\common\mbed\api; ..\..\..\component\os\RTX\INC; ..\..\..\component\os\RTX\rom\SRC; ..\..\..\component\os\RTX\rtl8195blp; ..\..\..\component\os\RTX\rom\rtl8195blp; ..\..\..\component\soc\realtek\8195b\mbed-hal\hal; ..\..\..\component\soc\realtek\8195b\mbed-hal\hal_ext; ..\..\..\component\soc\realtek\8195b\mbed-drivers\include; ..\..\..\component\soc\realtek\8195b\mbed-hal\targets\hal\rtl8195bl; ..\..\..\component\common\mbed\hal; ..\..\..\component\common\mbed\hal_ext; ..\..\..\component\common\mbed\targets\hal\rtl8195b\hal\rtl8195bl; ..\..\..\component\soc\realtek\8195b\misc\driver
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\inc; ..\..\..\component\os\freertos\freertos_v9.0.0\include; ..\..\..\component\os\freertos\freertos_v9.0.0\portable\IAR\ARM_Cv8M\r0p1; ..\..\..\component\os\freertos\freertos_v9.0.0\secure
  AARM.AExtraOptionsV2: --cmse
  OBJCOPY.OOCOutputFile: application.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkKeepSymbols: ram_start
  ILINK.IlinkIcfFile: application_lp.icf
  ILINK.IlinkExtraOptions: --skip_dynamic_initialization
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group cmsis
    ../../../component/soc/realtek/8195b/cmsis/rtl8195b-lp/source/: app_start.c
  group console
    ../../../component/soc/realtek/8195b/app/shell/: cmd_shell.c
  group lib
    ../../../component/soc/realtek/8195b/fwlib/hal-rtl8195b-lp/lib/lib/: hal_pmc_lp.a
    ../../../component/soc/realtek/8195b/misc/bsp/lib/common/IAR/: lib_soc_lp.a
  group os
    ../../../component/os/RTX/rtl8195blp/: cmsis_os_stubs.c RTX_Conf_CM.c RTX_os_callback.c
  group peripheral/api
    ../../../component/common/mbed/targets/hal/rtl8195b/hal/rtl8195bl/: analogin_api.c cir_api.c dma_api.c efuse_api.c gpio_api.c gpio_irq_api.c i2c_api.c icc_api.c pinmap.c pinmap_common.c power_mode_api.c pwmout_api.c rtc_api.c serial_api.c sgpio_api.c timer_api.c us_ticker.c us_ticker_api.c wait_api.c wdt_api.c
  group peripheral/hal
    ../../../component/soc/realtek/8195b/fwlib/hal-rtl8195b-lp/source/: hal_adc.c hal_cir.c hal_comp.c hal_efuse.c hal_i2c.c hal_icc.c hal_icc_app.c hal_pwm.c hal_qdec.c Hal_rtc.c hal_sgpio.c hal_timer.c hal_uart.c
  group user
    ../src/: main_lp.c
