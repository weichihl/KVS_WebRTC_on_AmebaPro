# IAR project application_is_LTS_test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: __thumb2__; CONFIG_PLATFORM_8195B; CONFIG_PLATFORM_8195BHP; __FPU_PRESENT; __ARM_ARCH_7M__=0; __ARM_ARCH_8M_MAIN__=1; __ARM_ARCH_8M_BASE__=0; CONFIG_BUILD_RAM=1; _NO_DEFINITIONS_IN_HEADER_FILES; ARM_MATH_CM7; V8M_STKOVF; CONFIG_FATFS_WRAPPER=1; MBEDTLS_CONFIG_FILE="aws_mbedtls_config.h"
  ICCARM.CCDiagSuppress: Pe1859
  ICCARM.IExtraOptions: --cmse; --enum_is_int; --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\component\soc\realtek\8195b\cmsis\rtl8195b-hp\include; ..\..\..\component\common\drivers\sdio\realtek\sdio_host\src; ..\..\..\component\soc\realtek\8195b\cmsis\cmsis-core\include; ..\..\..\component\soc\realtek\8195b\cmsis\rtl8195b-hp\lib\include; ..\..\..\component\soc\realtek\8195b\fwlib\hal-rtl8195b-hp\include; ..\..\..\component\soc\realtek\8195b\fwlib\hal-rtl8195b-hp\lib\include; ..\..\..\component\soc\realtek\8195b\app\rtl_printf\include; ..\..\..\component\soc\realtek\8195b\app\shell; ..\..\..\component\soc\realtek\8195b\app\stdio_port; ..\..\..\component\os\freertos; ..\..\..\component\os\freertos\freertos_v10.0.0\include; ..\..\..\component\os\freertos\freertos_v10.0.0\portable\IAR\ARM_RTL8195B; ..\..\..\component\os\freertos\freertos_v10.0.0\secure; ..\..\..\component\os\os_dep\include; ..\..\..\component\soc\realtek\8195b\misc\utilities\include; ..\..\..\component\soc\realtek\8195b\misc\platform; ..\..\..\component\soc\realtek\8195b\fwlib\hal-rtl8195b-hp\include\usb_otg; ..\..\..\component\soc\realtek\8195b\fwlib\hal-rtl8195b-hp\lib\video\video\include; ..\..\..\component\soc\realtek\8195b\fwlib\hal-rtl8195b-hp\lib\video\lcdc\include; ..\..\..\component\soc\realtek\8195b\fwlib\hal-rtl8195b-hp\lib\video\isp\include; ..\..\..\component\common\api; ..\..\..\component\common\api\at_cmd; ..\..\..\component\common\api\platform; ..\..\..\component\common\api\wifi; ..\..\..\component\common\api\network\include; ..\..\..\component\common\audio\haac; ..\..\..\component\common\audio\speex; ..\..\..\component\common\network\lwip\lwip_v2.0.2\src\include; ..\..\..\component\common\network\lwip\lwip_v2.0.2\src\include\lwip; ..\..\..\component\common\network\lwip\lwip_v2.0.2\port\realtek; ..\..\..\component\common\network\lwip\lwip_v2.0.2\port\realtek\freertos; ..\..\..\component\common\drivers\wlan\realtek\include; ..\..\..\component\common\drivers\wlan\realtek\src\osdep; ..\..\..\component\soc\realtek\8195b\fwlib\hal-rtl8195b-hp\video\lcdc\include; ..\..\..\component\soc\realtek\8195b\fwlib\hal-rtl8195b-hp\video\isp\include; ..\..\..\component\soc\realtek\8195b\mbed-hal\hal; ..\..\..\component\soc\realtek\8195b\mbed-hal\hal_ext; ..\..\..\component\soc\realtek\8195b\fwlib\hal-rtl8195b-hp\include\usb_otg; ..\..\..\component\soc\realtek\8195b\fwlib\hal-rtl8195b-hp\video\video\include; ..\..\..\component\soc\realtek\8195b\fwlib\hal-rtl8195b-hp\video\lcdc\include; ..\..\..\component\soc\realtek\8195b\fwlib\hal-rtl8195b-hp\video\isp\include; ..\..\..\component\soc\realtek\8195b\mbed-drivers\include; ..\..\..\component\os\freertos; ..\..\..\component\os\os_dep\include; ..\..\..\component\common\media\mmfv2; ..\..\..\component\common\media\rtp_codec; ..\..\..\component\common\media\samples; ..\..\..\component\common\network; ..\..\..\component\common\example; ..\..\..\component\common\drivers\video\realtek\common; ..\..\..\component\common\drivers\video\realtek\common\h264enc\inc; ..\..\..\component\common\drivers\video\realtek\common\h264enc\source\common; ..\..\..\component\common\drivers\video\realtek\common\h264enc\source\camstab; ..\..\..\component\common\drivers\video\realtek\common\h264enc\source\h264; ..\..\..\component\common\drivers\video\realtek\common; ..\..\..\component\common\drivers\video\realtek\common\include; ..\..\..\component\soc\realtek\8195b\cmsis\cmsis-dsp\include; ..\..\..\component\common\audio\faac\libfaac; ..\..\..\component\common\audio\faac\include; ..\..\..\component\soc\realtek\8195b\mbed-hal\targets\hal\rtl8195bh; ..\..\..\component\common\file_system\fatfs; ..\..\..\component\common\file_system\fatfs\r0.14; ..\..\..\component\common\drivers\sdio\realtek\sdio_host\inc; ..\..\..\component\soc\realtek\8195b\cmsis\cmsis-core\include; ..\..\..\component\soc\realtek\8195a\fwlib\rtl8195a; ..\..\..\component\soc\realtek\8195a\misc\os; ..\..\..\component\soc\realtek\8195b\mbed-hal\targets\hal\rtl8195bh; ..\..\..\component\soc\realtek\8195b\fwlib\hal-rtl8195b-hp\lib\video\enc\include; ..\..\..\component\common\api\wifi\rtw_wpa_supplicant\src; ..\..\..\component\soc\realtek\8711b\swlib\std_lib\include; ..\..\..\component\common\network\http2\nghttp2-1.31.0\includes; ..\..\..\component\common\application\mqtt\MQTTClient; ..\..\..\component\common\network\coap\include; ..\..\..\component\common\network\ssl\polarssl-1.3.8\include; ..\..\..\component\common\network\ssl\mbedtls-2.16.4\include___; ..\..\..\component\common\network\ssl\mbedtls-2.16.6\include___; ..\..\..\component\common\network\ssl\ssl_ram_map\rom; ..\..\..\component\common\drivers\i2s; ..\..\..\component\common\utilities; ..\..\..\component\common\application; ..\..\..\component\soc\realtek\8195b\fwlib\hal-rtl8195b-hp\lib\include\usb_otg; ..\..\..\component\common\video\v4l2\inc; ..\..\..\component\common\drivers\usb_class\host\uvc\inc; ..\..\..\component\common\drivers\usb_class\device; ..\..\..\component\common\drivers\usb_class\device\class; ..\..\..\component\common\drivers\modules; ..\..\..\component\common\media\framework; ..\..\..\component\common\media\codec\mp3; ..\..\..\component\common\media\rtp_codec\mjpeg; ..\..\..\component\common\media\muxer; ..\..\..\component\common\media\mmfv2; ..\..\..\component\common\audio; ..\..\..\component\common\media\rtp_codec; ..\..\..\component\soc\realtek\8195b\app\xmodem\rom; ..\..\..\component\common\test; ..\..\..\component\common\file_system; ..\..\..\component\common\file_system\dct; ..\..\..\component\common\drivers\video\realtek\common\include\feature; ..\..\..\component\common\mbed\hal; ..\..\..\component\common\mbed\hal_ext; ..\..\..\component\common\mbed\targets\hal\rtl8195b\hal\rtl8195bh; ..\..\..\component\common\application\qr_code_scanner\inc; ..\..\..\component\soc\realtek\8195b\misc\driver; ..\src\eval\sensor_board_v1; ..\..\..\component\common\audio\hmp3; ..\..\..\component\common\media\AlgoObjDetect; ..\..\..\component\os\freertos\freertos_v10.0.0\portable\posix\lib\include; ..\..\..\component\os\freertos\freertos_v10.0.0\portable\posix\lib\FreeRTOS-Plus-POSIX\include\portable\realtek\rtl8195; ..\..\..\component\os\freertos\freertos_v10.0.0\portable\posix\lib\FreeRTOS-Plus-POSIX\include; ..\..\..\component\os\freertos\freertos_v10.0.0\portable\posix\lib\include\private; ..\..\..\component\common\application\amazon\amazon-freertos-202012.00\libraries\3rdparty\mbedtls_utils; ..\..\..\component\common\application\amazon\amazon-freertos-202012.00\libraries\3rdparty\mbedtls_config; ..\..\..\component\common\application\amazon\amazon-freertos-202012.00\libraries\3rdparty\mbedtls\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: V8M_STKOVF
  AARM.AUserIncludes: ..\inc; ..\..\..\component\os\freertos\freertos_v9.0.0\include; ..\..\..\component\os\freertos\freertos_v9.0.0\portable\IAR\ARM_RTL8195B; ..\..\..\component\os\freertos\freertos_v9.0.0\secure
  OBJCOPY.OOCOutputFile: application_is_LTS.srec
  prebuild: CSCRIPT  "..\..\..\component\soc\realtek\8195b\misc\iar_utility\prebuild_is.vbs" "$TARGET_DIR$" "$PROJ_DIR$" "$CONFIG_NAME$" "$TOOLKIT_DIR$"
  postbuild: CSCRIPT  "..\..\..\component\soc\realtek\8195b\misc\iar_utility\postbuild_is.vbs" "$TARGET_DIR$" "$PROJ_DIR$" "$CONFIG_NAME$" "$TOOLKIT_DIR$"
  ILINK.IlinkOutputFile: application_is.out
  ILINK.IlinkKeepSymbols: ram_start; cinit_start
  ILINK.IlinkIcfFile: application_is.icf
  ILINK.IlinkExtraOptions: --redirect malloc=__wrap_malloc; --redirect realloc=__wrap_realloc; --redirect calloc=__wrap_calloc; --redirect free=__wrap_free; --redirect printf=__wrap_printf; --redirect sprintf_________=__wrap_sprintf; --redirect snprintf__________=__wrap_snprintf; --redirect vsprintf_______=__wrap_vsprintf; --redirect vsnprintf____________=__wrap_vsnprintf; --redirect memcmp=__wrap_memcmp; --redirect memcpy=__wrap_memcpy; --redirect memmove=__wrap_memmove; --redirect memset=__wrap_memset; --redirect strcat=__wrap_strcat; --redirect strchr=__wrap_strchr; --redirect strcmp=__wrap_strcmp; --redirect strncmp=__wrap_strncmp; --redirect strnicmp=__wrap_strnicmp; --redirect strcpy=__wrap_strcpy; --redirect strncpy=__wrap_strncpy; --redirect strlcpy=__wrap_strlcpy; --redirect strlen=__wrap_strlen; --redirect strnlen=__wrap_strnlen; --redirect strncat=__wrap_strncat; --redirect strpbrk=__wrap_strpbrk; --redirect strspn=__wrap_strspn; --redirect strstr=__wrap_strstr; --redirect strtok=__wrap_strtok; --redirect strxfrm=__wrap_strxfrm; --redirect strsep=__wrap_strsep; --redirect strtod=__wrap_strtod; --redirect strtof=__wrap_strtof; --redirect strtold=__wrap_strtold; --redirect strtoll=__wrap_strtoll; --redirect strtoul=__wrap_strtoul; --redirect strtoull=__wrap_strtoull; --redirect atoi=__wrap_atoi; --redirect atoui=__wrap_atoui; --redirect atol=__wrap_atol; --redirect atoul=__wrap_atoul; --redirect atoull=__wrap_atoull; --redirect atof=__wrap_atof; --redirect abort=__wrap_abort; --redirect opendir=__wrap_opendir; --redirect readdir=__wrap_readdir; --redirect closedir=__wrap_closedir; --redirect scandir=__wrap_scandir; --redirect rmdir=__wrap_rmdir; --redirect mkdir=__wrap_mkdir; --redirect access=__wrap_access; --redirect stat=__wrap_stat
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group @CINIT
    ../../../component/soc/realtek/8195b/fwlib/hal-rtl8195b-hp/source/ram/: hal_timer.c
    ../../../component/os/freertos/freertos_v10.0.0/portable/MemMang/: heap_4_2.c
    ../src/: isp_boot_config.c
    ../../../component/soc/realtek/8195b/misc/utilities/source/ram/: libc_wrap.c
  group @ITCM/network/lwip
    ../../../component/common/network/dhcp/: dhcps.c
  group @ITCM/network/lwip/api
    ../../../component/common/network/lwip/lwip_v2.0.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group @ITCM/network/lwip/core
    ../../../component/common/network/lwip/lwip_v2.0.2/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group @ITCM/network/lwip/core/ipv4
    ../../../component/common/network/lwip/lwip_v2.0.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group @ITCM/network/lwip/core/ipv6
    ../../../component/common/network/lwip/lwip_v2.0.2/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group @ITCM/network/lwip/netif
    ../../../component/common/network/lwip/lwip_v2.0.2/src/netif/: ethernet.c
  group @ITCM/network/lwip/netif/ppp
    ../../../component/common/network/lwip/lwip_v2.0.2/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c lwip_ecp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
    ../../../component/common/network/lwip/lwip_v2.0.2/src/netif/ppp/polarssl/: lwip_md5.c
  group @ITCM/network/lwip/port
    ../../../component/common/network/lwip/lwip_v2.0.2/port/realtek/freertos/: ethernetif.c sys_arch.c
    ../../../component/common/drivers/wlan/realtek/src/osdep/: lwip_intf.c
  group @ITCM/os
    ../../../component/os/freertos/: cmsis_os.c freertos_cb.c freertos_service.c
    ../../../component/os/os_dep/: device_lock.c osdep_service.c
    ../../../component/common/network/sntp/: sntp.c
  group @ITCM/os/freertos
    ../../../component/os/freertos/freertos_v10.0.0/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group @ITCM/os/freertos/portable
    ../../../component/os/freertos/freertos_v10.0.0/portable/MemMang/: heap_4.c
    ../../../component/os/freertos/freertos_v10.0.0/portable/IAR/ARM_RTL8195B/: port.c portasm.s
  group @ITCM/os/freertos/portable/posix
    ../../../component/os/freertos/freertos_v10.0.0/portable/posix/lib/FreeRTOS-Plus-POSIX/source/: FreeRTOS_POSIX_clock.c FreeRTOS_POSIX_mqueue.c FreeRTOS_POSIX_pthread.c FreeRTOS_POSIX_pthread_barrier.c FreeRTOS_POSIX_pthread_cond.c FreeRTOS_POSIX_pthread_mutex.c FreeRTOS_POSIX_sched.c FreeRTOS_POSIX_semaphore.c FreeRTOS_POSIX_timer.c FreeRTOS_POSIX_unistd.c FreeRTOS_POSIX_utils.c
  group @SRAM
    ../../../component/common/mbed/targets/hal/rtl8195b/hal/rtl8195bh/: flash_api.c
    ../../../component/soc/realtek/8195b/misc/driver/: flash_api_ext.c
    ../../../component/common/file_system/fatfs/disk_if/src/: flash_fatfs.c
    ../../../component/soc/realtek/8195b/fwlib/hal-rtl8195b-hp/source/ram_s/: hal_flash.c
  group amazon-LTS/demos/common/http_demo_helpers
    ../../../component/common/application/amazon/amazon-freertos-202012.00/demos/common/http_demo_helpers/: http_demo_utils.c
  group amazon-LTS/demos/common/mqtt_demo_helpers
    ../../../component/common/application/amazon/amazon-freertos-202012.00/demos/common/mqtt_demo_helpers/: mqtt_demo_helpers.c
  group amazon-LTS/demos/common/pkcs11_helpers
    ../../../component/common/application/amazon/amazon-freertos-202012.00/demos/common/pkcs11_helpers/: pkcs11_helpers.c
  group amazon-LTS/demos/coreHTTP
    ../../../component/common/application/amazon/amazon-freertos-202012.00/demos/coreHTTP/: http_demo_mutual_auth.c
    ../../../component/common/application/amazon/JPEG_snapshot_s3_upload_example/: http_demo_s3_upload.c
  group amazon-LTS/demos/coreMQTT
    ../../../component/common/application/amazon/amazon-freertos-202012.00/demos/coreMQTT/: mqtt_demo_mutual_auth.c
  group amazon-LTS/demos/demo_runner
    ../../../component/common/application/amazon/amazon-freertos-202012.00/demos/demo_runner/: aws_demo.c aws_demo_version.c iot_demo_freertos.c iot_demo_runner.c
  group amazon-LTS/demos/dev_mode_key_provisioning
    ../../../component/common/application/amazon/amazon-freertos-202012.00/demos/dev_mode_key_provisioning/src/: aws_dev_mode_key_provisioning.c
  group amazon-LTS/demos/device_shadow_for_aws
    ../../../component/common/application/amazon/amazon-freertos-202012.00/demos/device_shadow_for_aws/: shadow_demo_main.c
  group amazon-LTS/demos/network_manager
    ../../../component/common/application/amazon/amazon-freertos-202012.00/demos/network_manager/: aws_iot_demo_network.c aws_iot_network_manager.c
  group amazon-LTS/demos/ota
    ../../../component/common/application/amazon/amazon-freertos-202012.00/demos/ota/: aws_iot_ota_update_demo.c
  group amazon-LTS/libraries/3rdparty/jsmn
    ../../../component/common/application/amazon/amazon-freertos-202012.00/libraries/3rdparty/jsmn/: jsmn.c
  group amazon-LTS/libraries/3rdparty/mbedtls/library
    ../../../component/common/application/amazon/amazon-freertos-202012.00/libraries/3rdparty/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group amazon-LTS/libraries/3rdparty/mbedtls_utils
    ../../../component/common/application/amazon/amazon-freertos-202012.00/libraries/3rdparty/mbedtls_utils/: mbedtls_error.c mbedtls_utils.c
  group amazon-LTS/libraries/3rdparty/tinycbor
    ../../../component/common/application/amazon/amazon-freertos-202012.00/libraries/3rdparty/tinycbor/src/: cborencoder.c cborencoder_close_container_checked.c cborerrorstrings.c cborparser.c cborparser_dup_string.c cborpretty.c cborpretty_stdio.c cborvalidation.c
  group amazon-LTS/libraries/3rdparty/unity
    ../../../component/common/application/amazon/amazon-freertos-202012.00/libraries/3rdparty/unity/src/: unity.c
    ../../../component/common/application/amazon/amazon-freertos-202012.00/libraries/3rdparty/unity/extras/fixture/src/: unity_fixture.c
  group amazon-LTS/libraries/abstractions/backoff_algorithm
    ../../../component/common/application/amazon/amazon-freertos-202012.00/libraries/abstractions/backoff_algorithm/source/: backoff_algorithm.c
  group amazon-LTS/libraries/abstractions/pkcs11/corePKCS11
    ../../../component/common/application/amazon/amazon-freertos-202012.00/libraries/abstractions/pkcs11/corePKCS11/source/: core_pkcs11.c core_pki_utils.c
  group amazon-LTS/libraries/abstractions/pkcs11/corePKCS11/portable/mbedtls
    ../../../component/common/application/amazon/amazon-freertos-202012.00/libraries/abstractions/pkcs11/corePKCS11/source/portable/mbedtls/: core_pkcs11_mbedtls.c
  group amazon-LTS/libraries/abstractions/platform/freertos
    ../../../component/common/application/amazon/amazon-freertos-202012.00/libraries/abstractions/platform/freertos/: iot_clock_freertos.c iot_metrics.c iot_network_freertos.c iot_threads_freertos.c
  group amazon-LTS/libraries/abstractions/test
    ../../../component/common/application/amazon/amazon-freertos-202012.00/libraries/abstractions/pkcs11/test/: iot_test_pkcs11.c
    ../../../component/common/application/amazon/amazon-freertos-202012.00/libraries/abstractions/secure_sockets/test/: iot_test_tcp.c
    ../../../component/common/application/amazon/amazon-freertos-202012.00/libraries/abstractions/wifi/test/: iot_test_wifi.c
  group amazon-LTS/libraries/abstractions/transport/secure_sockets
    ../../../component/common/application/amazon/amazon-freertos-202012.00/libraries/abstractions/transport/secure_sockets/: transport_secure_sockets.c
  group amazon-LTS/libraries/c_sdk/aws/defender
    ../../../component/common/application/amazon/amazon-freertos-202012.00/libraries/c_sdk/aws/defender/src/: aws_iot_defender_api.c aws_iot_defender_collector.c aws_iot_defender_mqtt.c aws_iot_defender_v1.c
  group amazon-LTS/libraries/c_sdk/aws/shadow
    ../../../component/common/application/amazon/amazon-freertos-202012.00/libraries/c_sdk/aws/shadow/src/: aws_iot_shadow_api.c aws_iot_shadow_operation.c aws_iot_shadow_parser.c aws_iot_shadow_static_memory.c aws_iot_shadow_subscription.c aws_shadow.c
  group amazon-LTS/libraries/c_sdk/standard/common
    ../../../component/common/application/amazon/amazon-freertos-202012.00/libraries/c_sdk/standard/common/: iot_device_metrics.c iot_init.c iot_static_memory_common.c
  group amazon-LTS/libraries/c_sdk/standard/common/taskpool
    ../../../component/common/application/amazon/amazon-freertos-202012.00/libraries/c_sdk/standard/common/taskpool/: iot_taskpool.c iot_taskpool_static_memory.c
  group amazon-LTS/libraries/c_sdk/standard/https
    ../../../component/common/application/amazon/amazon-freertos-202012.00/libraries/c_sdk/standard/https/src/: iot_https_client.c iot_https_utils.c
  group amazon-LTS/libraries/c_sdk/standard/mqtt
    ../../../component/common/application/amazon/amazon-freertos-202012.00/libraries/c_sdk/standard/mqtt/src/: iot_mqtt_agent.c iot_mqtt_api.c iot_mqtt_context_connection.c iot_mqtt_managed_function_wrapper.c iot_mqtt_mutex_wrapper.c iot_mqtt_network.c iot_mqtt_operation.c iot_mqtt_publish_duplicates.c iot_mqtt_serializer_deserializer_wrapper.c iot_mqtt_static_memory.c iot_mqtt_subscription.c iot_mqtt_subscription_container.c iot_mqtt_validate.c
  group amazon-LTS/libraries/c_sdk/standard/test
    ../../../component/common/application/amazon/amazon-freertos-202012.00/libraries/c_sdk/standard/mqtt/test/: iot_test_mqtt_agent.c
    ../../../component/common/application/amazon/amazon-freertos-202012.00/libraries/c_sdk/standard/mqtt/test/unit/: iot_tests_mqtt_api.c iot_tests_mqtt_metrics.c iot_tests_mqtt_receive.c iot_tests_mqtt_subscription.c iot_tests_mqtt_validate.c
    ../../../component/common/application/amazon/amazon-freertos-202012.00/libraries/c_sdk/standard/mqtt/test/mock/: iot_tests_mqtt_mock.c
    ../../../component/common/application/amazon/amazon-freertos-202012.00/libraries/c_sdk/standard/mqtt/test/system/: iot_tests_mqtt_system.c
  group amazon-LTS/libraries/coreHTTP
    ../../../component/common/application/amazon/amazon-freertos-202012.00/libraries/coreHTTP/source/: core_http_client.c
  group amazon-LTS/libraries/coreHTTP/http_parser
    ../../../component/common/application/amazon/amazon-freertos-202012.00/libraries/coreHTTP/source/dependency/3rdparty/http_parser/: http_parser.c
  group amazon-LTS/libraries/coreJSON
    ../../../component/common/application/amazon/amazon-freertos-202012.00/libraries/coreJSON/source/: core_json.c
  group amazon-LTS/libraries/coreMQTT
    ../../../component/common/application/amazon/amazon-freertos-202012.00/libraries/coreMQTT/source/: core_mqtt.c core_mqtt_serializer.c core_mqtt_state.c
  group amazon-LTS/libraries/device_shadow_for_aws
    ../../../component/common/application/amazon/amazon-freertos-202012.00/libraries/device_shadow_for_aws/source/: shadow.c
  group amazon-LTS/libraries/freertos_plus/aws
    ../../../component/common/application/amazon/amazon-freertos-202012.00/libraries/freertos_plus/aws/ota/src/: aws_iot_ota_agent.c aws_iot_ota_interface.c
    ../../../component/common/application/amazon/amazon-freertos-202012.00/libraries/freertos_plus/aws/ota/src/mqtt/: aws_iot_ota_cbor.c aws_iot_ota_mqtt.c
  group amazon-LTS/libraries/freertos_plus/standard/crypto
    ../../../component/common/application/amazon/amazon-freertos-202012.00/libraries/freertos_plus/standard/crypto/src/: iot_crypto.c
  group amazon-LTS/libraries/freertos_plus/standard/tls
    ../../../component/common/application/amazon/amazon-freertos-202012.00/libraries/freertos_plus/standard/tls/src/: iot_tls.c
  group amazon-LTS/libraries/freertos_plus/standard/utils
    ../../../component/common/application/amazon/amazon-freertos-202012.00/libraries/freertos_plus/standard/utils/src/: iot_system_init.c
  group amazon-LTS/libraries/freertos_plus/test
    ../../../component/common/application/amazon/amazon-freertos-202012.00/libraries/freertos_plus/standard/tls/test/: iot_test_tls.c
  group amazon-LTS/libraries/freertos_plus/test/ota
    ../../../component/common/application/amazon/amazon-freertos-202012.00/libraries/freertos_plus/aws/ota/test/: aws_test_ota_agent.c aws_test_ota_pal.c
  group amazon-LTS/libraries/logging
    ../../../component/common/application/amazon/amazon-freertos-202012.00/libraries/logging/: iot_logging.c iot_logging_task_dynamic_buffers.c
  group amazon-LTS/tests/common
    ../../../component/common/application/amazon/amazon-freertos-202012.00/tests/common/: aws_test_framework.c aws_test_runner.c iot_tests_network.c
  group amazon-LTS/tests/integration_test
    ../../../component/common/application/amazon/amazon-freertos-202012.00/tests/integration_test/: core_http_system_test.c core_mqtt_system_test.c
  group amazon-LTS/vendor
    ../../../component/common/application/amazon/amazon-freertos-202012.00/vendors/realtek/boards/amebaPro/aws_demos/application_code/: aws_main.c
    ../../../component/common/application/amazon/amazon-freertos-202012.00/vendors/realtek/boards/amebaPro/aws_tests/application_code/: aws_test_main.c
    ../../../component/common/example/amazon_afqp_tests/: example_amazon_afqp_tests.c
    ../../../component/common/example/amazon_freertos/: example_amazon_freertos.c
  group amazon-LTS/vendor/port
    ../../../component/common/application/amazon/amazon-freertos-202012.00/vendors/realtek/boards/amebaPro/ports/ota/: aws_ota_amebapro.c aws_ota_pal.c
    ../../../component/common/application/amazon/amazon-freertos-202012.00/vendors/realtek/boards/amebaPro/ports/pkcs11/: core_pkcs11_pal.c
    ../../../component/common/application/amazon/amazon-freertos-202012.00/vendors/realtek/boards/amebaPro/ports/secure_sockets/: iot_secure_sockets.c
    ../../../component/common/application/amazon/amazon-freertos-202012.00/vendors/realtek/boards/amebaPro/ports/wifi/: iot_wifi.c
  group cmsis
    ../../../component/soc/realtek/8195b/cmsis/rtl8195b-hp/source/ram_s/: app_start.c
    ../../../component/soc/realtek/8195b/cmsis/rtl8195b-hp/source/ram/: mpu_config.c
  group cmsis/dsp
    ../../../component/soc/realtek/8195b/cmsis/cmsis-dsp/source/BasicMathFunctions/: arm_add_f32.c arm_mult_f32.c arm_scale_f32.c
    ../../../component/soc/realtek/8195b/cmsis/cmsis-dsp/source/TransformFunctions/: arm_bitreversal2.S arm_cfft_f32.c arm_cfft_radix8_f32.c arm_rfft_fast_f32.c arm_rfft_fast_init_f32.c
    ../../../component/soc/realtek/8195b/cmsis/cmsis-dsp/source/ComplexMathFunctions/: arm_cmplx_mag_f32.c
    ../../../component/soc/realtek/8195b/cmsis/cmsis-dsp/source/CommonTables/: arm_common_tables.c arm_const_structs.c
    ../../../component/soc/realtek/8195b/cmsis/cmsis-dsp/source/StatisticsFunctions/: arm_max_f32.c
  group console
    ../../../component/common/api/at_cmd/: atcmd_ethernet.c atcmd_isp.c atcmd_lwip.c atcmd_media.c atcmd_qr_code.c atcmd_sys.c atcmd_wifi.c
    ../../../component/soc/realtek/8195b/app/shell/: cmd_shell.c
    ../../../component/soc/realtek/8195b/misc/driver/: log_service.c low_level_io.c rtl_console.c
  group lib
    ../../../component/soc/realtek/8195b/fwlib/hal-rtl8195b-hp/lib/lib/: hal_pmc_hs.a
    ../../../component/soc/realtek/8195b/misc/bsp/lib/common/IAR/: lib_codec.a lib_dct.a lib_faac.a lib_h264.a lib_haac.a lib_hmp3.a lib_http.a lib_mdns.a lib_mmf.a lib_muxer.a lib_opus.a lib_opusenc.a lib_opusfile.a lib_p2p.a lib_qr_code.a lib_rtsp.a lib_sdcard.a lib_soc_is.a lib_speex.a lib_tftp.a lib_usbd.a lib_usbh.a lib_websocket.a lib_wlan.a lib_wlan_mp.a lib_wps.a libAlgoObjDetectLib.a librtscamkit.a librtsisp.a librtsosd.a librtstream.a librtsv4l2.a
  group lib/amazon
    ../../../component/soc/realtek/8195b/misc/bsp/lib/common/IAR/: lib_kvs_producer.a lib_kvs_webrtc.a lib_webrtc_pic.a lib_webrtc_producer_c.a libsrtp2.a libusrsctp.a libwebsockets.a
  group multimedia
    ../../../component/common/drivers/video/realtek/common/: encoder_buffer_handler.c
    ../../../component/common/media/framework/: jpeg_snapshot.c mmf_command.c snapshot_sd_handler.c snapshot_tftp_handler.c
    ../../../component/common/media/: media_amebacam_broadcast.c
  group multimedia/mmfv2
    ../../../component/common/media/mmfv2/: module_aac.c module_aad.c module_array.c module_audio.c module_dual_uvcd.c module_dup.c module_g711.c module_h264.c module_httpfs.c module_i2s.c module_isp.c module_jpeg.c module_mp4.c module_opencv.c module_rtp.c module_rtsp2.c module_uvcd.c module_uvch.c
  group multimedia/mmfv2_example
    ../../../component/common/example/media_framework/: mmf2_example_2way_audio_init.c mmf2_example_a_init.c mmf2_example_aac_array_rtsp_init.c mmf2_example_aacloop_init.c mmf2_example_audioloop_init.c mmf2_example_av21_init.c mmf2_example_av2_init.c mmf2_example_av_dup_init.c mmf2_example_av_init.c mmf2_example_av_mp4_httpfs_init.c mmf2_example_av_mp4_init.c mmf2_example_av_rtsp_mp4_init.c mmf2_example_g711loop_init.c mmf2_example_h264_2way_audio_pcmu_doorbell_init.c mmf2_example_h264_2way_audio_pcmu_init.c mmf2_example_h264_array_rtsp_init.c mmf2_example_i2s_audio_init.c mmf2_example_joint_test_init.c mmf2_example_joint_test_rtsp_mp4_init.c mmf2_example_mp4_dual_init.c mmf2_example_param.c mmf2_example_pcmu_array_rtsp_init.c mmf2_example_rtp_aad_init.c mmf2_example_simo_init.c mmf2_example_v1_init.c mmf2_example_v1_param_change_init.c mmf2_example_v2_init.c mmf2_example_v3_init.c snapshot_setting.c
    ../../../component/common/example/media_uvcd/: usbd_dual_uvc_parm.c usbd_uvc_parm.c
  group multimedia/sensor
    ../../../component/common/media/framework/: sensor_service.c
  group network
    ../../../component/common/drivers/wlan/realtek/src/core/option/: rtw_opt_skbuf.c
  group network/api
    ../../../component/common/api/: lwip_netconf.c
  group network/api/wifi
    ../../../component/common/api/wifi/: wifi_conf.c wifi_ind.c wifi_promisc.c wifi_simple_config.c wifi_util.c
  group network/api/wifi/rtw_wpa_supplicant
    ../../../component/common/api/wifi/rtw_wpa_supplicant/src/crypto/: tls_polarssl.c
    ../../../component/common/api/wifi/rtw_wpa_supplicant/wpa_supplicant/: wifi_eap_config.c wifi_p2p_config.c wifi_wps_config.c
  group network/app
    ../../../component/soc/realtek/8195b/misc/platform/: ota_8195b.c
    ../../../component/common/api/network/src/: ping_test.c wlan_network.c
    ../../../component/common/utilities/: ssl_client.c ssl_client_ext.c tcptest.c
  group network/app/mqtt
    ../../../component/common/application/mqtt/MQTTClient/: MQTTClient.c MQTTFreertos.c
    ../../../component/common/application/mqtt/MQTTPacket/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group network/coap
    ../../../component/common/network/coap/: sn_coap_ameba_port.c sn_coap_builder.c sn_coap_header_check.c sn_coap_parser.c sn_coap_protocol.c
  group network/googlenest
    ../../../component/common/application/google/: google_tls.c
  group network/http
    ../../../component/common/network/httpc/: httpc_tls.c
    ../../../component/common/network/httpd/: httpd_tls.c
  group network/mdns
    ../../../component/common/network/mDNS/: mDNSPlatform.c
  group network/ssl/mbedtls
    ../../../component/common/network/ssl/mbedtls-2.16.4/library/: aes.c aes_alt.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_alt.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_alt.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c timing_alt.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group network/ssl/mbedtls_2.16.6
    ../../../component/common/network/ssl/mbedtls-2.16.6/library/: aes.c aes_alt.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_alt.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group network/ssl/ssl_ram_map
    ../../../component/common/network/ssl/ssl_ram_map/rom/: rom_ssl_ram_map.c
    ../../../component/common/network/ssl/ssl_func_stubs/: ssl_func_stubs.c
  group network/websocket
    ../../../component/common/network/websocket/: wsclient_tls.c wsserver_tls.c
  group peripheral/api
    ../../../component/common/mbed/targets/hal/rtl8195b/hal/rtl8195bh/: analogin_api.c audio_api.c crypto_api.c dma_api.c efuse_api.c ethernet_api.c gpio_api.c gpio_irq_api.c i2c_api.c i2s_api.c icc_api.c objects.h pcm_api.c pinmap.c pinmap_common.c PinNames.h PortNames.h power_mode_api.c pwmout_api.c serial_api.c sgpio_api.c spdio_api.c spi_api.c sys_api.c timer_api.c us_ticker.c us_ticker_api.c wait_api.c wdt_api.c
    ../../../component/common/drivers/ethernet_mii/: ethernet_mii.c
  group peripheral/hal
    ../../../component/soc/realtek/8195b/fwlib/hal-rtl8195b-hp/source/ram_ns/: hal_adc.c hal_audio.c hal_eth.c hal_i2c.c hal_i2s.c hal_pcm.c hal_pwm.c hal_sdio_host.c hal_sgpio.c hal_ssi.c
    ../../../component/soc/realtek/8195b/fwlib/hal-rtl8195b-hp/source/ram_s/: hal_efuse.c hal_icc.c hal_spic.c
    ../../../component/soc/realtek/8195b/fwlib/hal-rtl8195b-hp/source/ram/: hal_gdma.c hal_gpio.c hal_icc_app.c hal_misc.c hal_uart.c
  group user
    ../src/: main.c
  group user/evalutaion_board/sensor_board_v1
    ../src/eval/sensor_board_v1/: AL3042.c ambient_light_sensor.c ir_ctrl.c ir_cut.c sensor_external_ctrl.c
  group utilities
    ../../../component/common/utilities/: cJSON.c http_client.c xml.c
  group utilities/example
    ../../../component/common/example/audio_helix_aac/: example_audio_helix_aac.c
    ../../../component/common/example/audio_helix_mp3/: example_audio_helix_mp3.c
    ../../../component/common/example/audio_loop/: example_audio_loop.c
    ../../../component/common/example/audio_opus_encode/: example_audio_opus_encode.c
    ../../../component/common/example/audio_to_aac/: example_audio_to_aac.c
    ../../../component/common/example/audio_to_g711/: example_audio_to_g711.c
    ../../../component/common/example/audio_to_opus/: example_audio_to_opus.c
    ../../../component/common/example/bcast/: example_bcast.c
    ../../../component/common/example/cJSON/: example_cJSON.c
    ../../../component/common/example/coap/: example_coap.c
    ../../../component/common/example/dct/: example_dct.c
    ../../../component/common/example/eap/: example_eap.c
    ../../../component/common/example/: example_entry.c
    ../../../component/common/example/fatfs/: example_fatfs.c
    ../../../component/common/example/get_beacon_frame/: example_get_beacon_frame.c
    ../../../component/common/example/high_load_memory_use/: example_high_load_memory_use.c
    ../../../component/common/example/http_client/: example_http_client.c
    ../../../component/common/example/http_download/: example_http_download.c
    ../../../component/common/example/httpc/: example_httpc.c
    ../../../component/common/example/httpd/: example_httpd.c
    ../../../component/common/example/isp/: example_isp_osd_multi.c example_mask.c example_md.c
    ../../../component/common/example/mcast/: example_mcast.c
    ../../../component/common/example/mdns/: example_mdns.c
    ../../../component/common/example/media_uvcd/: example_media_dual_uvcd.c example_media_uvcd.c
    ../../../component/common/example/media_framework/: example_media_framework.c
    ../../../component/common/example/media_h264_to_sdcard/: example_media_h264_to_sdcard.c
    ../../../component/common/example/media_mp4_demuxer/: example_media_mp4_demuxer.c
    ../../../component/common/example/mqtt/: example_mqtt.c
    ../../../component/common/example/nonblock_connect/: example_nonblock_connect.c
    ../../../component/common/example/ota_http/: example_ota_http.c
    ../../../component/common/example/ota_sdcard/: example_ota_sdcard.c
    ../../../component/common/example/pppoe/: example_pppoe.c
    ../../../component/common/example/qr_code_scanner/: example_qr_code_scanner.c
    ../../../component/common/example/rarp/: example_rarp.c
    ../../../component/common/example/sd_hot_plug/: example_sd_hotplug.c
    ../../../component/common/example/sdcard_upload_httpd/: example_sdcard_upload_httpd.c
    ../../../component/common/example/sntp_showtime/: example_sntp_showtime.c
    ../../../component/common/example/socket_select/: example_socket_select.c
    ../../../component/common/example/socket_tcp_trx/: example_socket_tcp_trx_1.c example_socket_tcp_trx_2.c
    ../../../component/common/example/std_file/: example_std_file.c
    ../../../component/common/example/tcp_keepalive/: example_tcp_keepalive.c
    ../../../component/common/example/usb_dfu_ota/: example_usb_dfu_ota.c
    ../../../component/common/example/usb_mass_storage/: example_usb_msc.c
    ../../../component/common/example/usbh_uvc/: example_usbh_uvc.c
    ../../../component/common/example/wifi_mac_monitor/: example_wifi_mac_monitor.c
    ../../../component/common/example/wifi_roaming/: example_wifi_roaming.c
    ../../../component/common/example/wlan_fast_connect/: example_wlan_fast_connect.c
    ../../../component/common/example/websocket_server/: example_ws_server.c
    ../../../component/common/example/websocket_client/: example_wsclient.c
    ../../../component/common/example/xml/: example_xml.c
  group utilities/example/kvs_producer
    ../../../component/common/example/kvs_producer/: example_kvs_producer.c kvs_producer.c
  group utilities/example/kvs_webrtc
    ../../../component/common/example/kvs_webrtc/: Common.c example_kvs_webrtc.c
  group utilities/FatFs
    ../../../component/common/file_system/fatfs/: fatfs_flash_api.c fatfs_reent.c fatfs_sdcard_api.c
  group utilities/FatFs/disk_if
    ../../../component/common/file_system/fatfs/disk_if/src/: sdcard.c usbdisk.c
    ../../../component/common/drivers/sdio/realtek/sdio_host/src/: sdio_combine.c
  group utilities/FatFs/fatfs_ext
    ../../../component/common/file_system/fatfs/fatfs_ext/src/: ff_driver.c
  group utilities/FatFs/r0.10c
    ../../../component/common/file_system/fatfs/r0.10c/src/: diskio.c ff.c
  group utilities/FatFs/r0.10c/option
    ../../../component/common/file_system/fatfs/r0.10c/src/option/: ccsbcs.c
  group utilities/FatFs/r0.14
    ../../../component/common/file_system/fatfs/r0.14/: diskio.c ff.c ffsystem.c ffunicode.c
