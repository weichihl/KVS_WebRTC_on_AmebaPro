# IAR project lib_opusenc.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: __thumb2__; CONFIG_PLATFORM_8195BHP; __FPU_PRESENT; __ARM_ARCH_7M__=0; __ARM_ARCH_8M_MAIN__=1; __ARM_ARCH_8M_BASE__=0; CONFIG_BUILD_RAM=1; _NO_DEFINITIONS_IN_HEADER_FILES; OUTSIDE_SPEEX; HAVE_CONFIG_H; DISABLE_FLOAT_API
  ICCARM.IExtraOptions: --cmse; --enum_is_int; --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\component\soc\realtek\8195b\cmsis\rtl8195b-hp\include; ..\..\..\component\common\drivers\sdio\realtek\sdio_host\src; ..\..\..\component\soc\realtek\8195b\cmsis\cmsis-core\include; ..\..\..\component\soc\realtek\8195b\cmsis\rtl8195b-hp\lib\include; ..\..\..\component\soc\realtek\8195b\fwlib\hal-rtl8195b-hp\include; ..\..\..\component\soc\realtek\8195b\fwlib\hal-rtl8195b-hp\lib\include; ..\..\..\component\soc\realtek\8195b\app\rtl_printf\include; ..\..\..\component\soc\realtek\8195b\app\shell; ..\..\..\component\soc\realtek\8195b\app\stdio_port; ..\..\..\component\os\os_dep\include; ..\..\..\component\soc\realtek\8195b\misc\utilities\include; ..\..\..\component\soc\realtek\8195b\misc\platform; ..\..\..\component\soc\realtek\8195b\fwlib\hal-rtl8195b-hp\include\usb_otg; ..\..\..\component\soc\realtek\8195b\fwlib\hal-rtl8195b-hp\lib\video\video\include; ..\..\..\component\soc\realtek\8195b\fwlib\hal-rtl8195b-hp\lib\video\lcdc\include; ..\..\..\component\soc\realtek\8195b\fwlib\hal-rtl8195b-hp\lib\video\isp\include; ..\..\..\component\common\api; ..\..\..\component\common\api\platform; ..\..\..\component\os\freertos; ..\..\..\component\os\freertos\freertos_v10.0.0\include; ..\..\..\component\os\freertos\freertos_v10.0.0\portable\IAR\ARM_RTL8195B; ..\..\..\component\soc\realtek\8195b\cmsis\rtl8195b-hp\include; ..\..\..\component\common\file_system\fatfs\r0.14; ..\..\..\component\common\file_system\fatfs; ..\..\..\component\common\audio\opus-1.3.1\include; ..\..\..\component\common\audio\libopusenc-0.2.1\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  ILINK.IlinkOutputFile: lib_opusfile.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group (top)
    ../../../component/common/audio/libopusenc-0.2.1/src/: ogg_packer.c opus_header.c opusenc.c resample.c unicode_support.c
