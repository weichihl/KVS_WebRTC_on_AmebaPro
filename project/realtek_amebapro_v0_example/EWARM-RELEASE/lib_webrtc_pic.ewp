# IAR project lib_webrtc_pic.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: __thumb2__; CONFIG_PLATFORM_8195BHP; __FPU_PRESENT; __ARM_ARCH_7M__=0; __ARM_ARCH_8M_MAIN__=1; __ARM_ARCH_8M_BASE__=0; CONFIG_BUILD_RAM=1; _NO_DEFINITIONS_IN_HEADER_FILES; __IEEE_LITTLE_ENDIAN
  ICCARM.IExtraOptions: --cmse; --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\lib_amazon\iar_include; ..\..\..\lib_amazon\amazon-kinesis-video-streams-pic\src\common\include; ..\..\..\lib_amazon\amazon-kinesis-video-streams-pic\src\state\include; ..\..\..\lib_amazon\amazon-kinesis-video-streams-pic\src\utils\include; ..\..\..\lib_amazon\amazon-kinesis-video-streams-pic\src\mkvgen\include; ..\..\..\component\os\freertos\freertos_v10.0.0\portable\posix\lib\include; ..\..\..\component\os\freertos\freertos_v10.0.0\portable\posix\lib\FreeRTOS-Plus-POSIX\include\portable\realtek\rtl8195; ..\..\..\component\os\freertos\freertos_v10.0.0\portable\posix\lib\FreeRTOS-Plus-POSIX\include; ..\..\..\component\os\freertos\freertos_v10.0.0\portable\posix\lib\include\private; ..\..\..\component\common\file_system\fatfs\r0.14; ..\..\..\component\os\freertos; ..\..\..\component\common\api\platform; ..\..\..\component\os\freertos\freertos_v10.0.0\include; ..\..\..\component\soc\realtek\8195b\cmsis\rtl8195b-hp\include; ..\..\..\component\os\freertos\freertos_v10.0.0\portable\IAR\ARM_RTL8195B; ..\..\..\component\common\api; ..\..\..\component\common\file_system\fatfs; ..\..\..\component\os\freertos\freertos_v10.0.0\portable\posix\lib\FreeRTOS-Plus-POSIX\include\portable\realtek\rtl8195
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  ILINK.IlinkOutputFile: lib_webrtc_pic.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group state
    ../../../lib_amazon/amazon-kinesis-video-streams-pic/src/state/src/: State.c
  group utils
    ../../../lib_amazon/amazon-kinesis-video-streams-pic/src/utils/src/: Allocators.c Atomics.c Base64.c BitField.c BitReader.c Crc32.c Directory.c DoubleLinkedList.c DynamicLibrary.c Endianness.c FileIo.c FileLogger.c HashTable.c Hex.c InstrumentedAllocators.c Logger.c Mutex.c Semaphore.c SingleLinkedList.c StackQueue.c String.c Tags.c Thread.c Time.c TimerQueue.c Version.c
