# IAR project lib_kvs_producer.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: __thumb2__; CONFIG_PLATFORM_8195BHP; __FPU_PRESENT; CONFIG_BUILD_RAM=1; __ARM_ARCH_7M__=0; __ARM_ARCH_8M_MAIN__=1; __ARM_ARCH_8M_BASE__=0; ENABLE_LOG_ERROR; ENABLE_LOG_WARN; ENABLE_LOG_INFO
  ICCARM.IExtraOptions: --cmse; --enum_is_int; --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\component\common\network\ssl\mbedtls-2.16.6\include; ..\..\..\component\common\network\ssl\ssl_ram_map\rom; ..\..\..\component\os\freertos; ..\..\..\component\os\freertos\freertos_v10.0.0\include; ..\..\..\component\os\freertos\freertos_v10.0.0\portable\IAR\ARM_RTL8195B; ..\..\..\component\os\freertos\freertos_v10.0.0\secure; ..\..\..\component\os\os_dep\include; ..\..\..\component\common\api; ..\..\..\component\common\api\platform; ..\..\..\component\common\api\network\include; ..\..\..\component\common\api\wifi; ..\..\..\component\soc\realtek\8195b\misc\utilities\include; ..\..\..\component\soc\realtek\8195b\cmsis\cmsis-core\include; ..\..\..\component\soc\realtek\8195b\app\rtl_printf\include; ..\..\..\component\soc\realtek\8195b\cmsis\rtl8195b-hp\include; ..\..\..\component\soc\realtek\8195b\cmsis\rtl8195b-hp\lib\include; ..\..\..\component\soc\realtek\8195b\app\stdio_port; ..\..\..\component\soc\realtek\8195b\misc\utilities\include; ..\..\..\component\soc\realtek\8195b\mbed-hal\hal_ext; ..\..\..\component\soc\realtek\8195b\mbed-hal\targets\hal\rtl8195bh; ..\..\..\component\soc\realtek\8195b\fwlib\hal-rtl8195b-hp\include; ..\..\..\component\soc\realtek\8195b\fwlib\hal-rtl8195b-hp\lib\include; ..\..\..\component\soc\realtek\8195b\fwlib\hal-rtl8195b-hp\include\usb_otg; ..\..\..\component\soc\realtek\8195b\fwlib\hal-rtl8195b-hp\lib\include\usb_otg; ..\..\..\component\soc\realtek\8195b\fwlib\hal-rtl8195b-hp\lib\video\isp\include; ..\..\..\component\common\network\lwip\lwip_v2.0.2\src\include; ..\..\..\component\common\network\lwip\lwip_v2.0.2\src\include\lwip; ..\..\..\component\common\network\lwip\lwip_v2.0.2\port\realtek; ..\..\..\component\common\network\lwip\lwip_v2.0.2\port\realtek\freertos; ..\..\..\component\common\file_system\fatfs; ..\..\..\component\common\file_system\fatfs\r0.14; ..\..\..\component\os\freertos\freertos_v10.0.0\portable\posix\lib\include; ..\..\..\component\os\freertos\freertos_v10.0.0\portable\posix\lib\FreeRTOS-Plus-POSIX\include\portable\realtek\rtl8195; ..\..\..\component\os\freertos\freertos_v10.0.0\portable\posix\lib\FreeRTOS-Plus-POSIX\include; ..\..\..\component\os\freertos\freertos_v10.0.0\portable\posix\lib\include\private; ..\..\..\component\os\freertos\freertos_v10.0.0\portable\IAR\ARM_RTL8195B; ..\..\..\lib_amazon\amazon-kinesis-video-streams-producer-embedded-c\libraries\aws\coreHTTP\source\include; ..\..\..\lib_amazon\amazon-kinesis-video-streams-producer-embedded-c\libraries\aws\coreHTTP\source\interface; ..\..\..\lib_amazon\amazon-kinesis-video-streams-producer-embedded-c\libraries\aws\coreHTTP\source\dependency\3rdparty\http_parser; ..\..\..\lib_amazon\amazon-kinesis-video-streams-producer-embedded-c\libraries\3rdparty\parson; ..\..\..\lib_amazon\amazon-kinesis-video-streams-producer-embedded-c\src\include; ..\..\..\lib_amazon\iar_include; ..\..\..\lib_amazon\llhttp\include; ..\..\..\lib_amazon\amazon-kinesis-video-streams-producer-embedded-c\libraries\3rdparty\c-utility\inc; ..\..\..\lib_amazon\amazon-kinesis-video-streams-producer-embedded-c\libraries\3rdparty\c-utility\deps\umock-c\inc; ..\..\..\lib_amazon\amazon-kinesis-video-streams-producer-embedded-c\libraries\3rdparty\c-utility\deps\azure-macro-utils-c\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  ILINK.IlinkOutputFile: lib_mmf.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  group c-utility/pal
    ../../../lib_amazon/amazon-kinesis-video-streams-producer-embedded-c/libraries/3rdparty/c-utility/pal/freertos/: lock.c
  group c-utility/src
    ../../../lib_amazon/amazon-kinesis-video-streams-producer-embedded-c/libraries/3rdparty/c-utility/src/: buffer.c consolelogger.c crt_abstractions.c doublylinkedlist.c httpheaders.c map.c strings.c xlogging.c
  group coreHTTP
    ../../../lib_amazon/amazon-kinesis-video-streams-producer-embedded-c/libraries/aws/coreHTTP/source/: core_http_client.c
    ../../../lib_amazon/amazon-kinesis-video-streams-producer-embedded-c/libraries/aws/coreHTTP/source/dependency/3rdparty/http_parser/: http_parser.c
  group llhttp
    ../../../lib_amazon/llhttp/src/: api.c http.c llhttp.c
  group parson
    ../../../lib_amazon/amazon-kinesis-video-streams-producer-embedded-c/libraries/3rdparty/parson/: parson.c
  group producer
    ../../../lib_amazon/amazon-kinesis-video-streams-producer-embedded-c/src/source/: aws_signer_v4.c http_helper.c iot_credential_provider.c json_helper.c mkv_generator.c nalu.c netio.c restapi.c sps_decode.c stream.c
    ../../../lib_amazon/iar_port/: kvs_port_freertos.c
