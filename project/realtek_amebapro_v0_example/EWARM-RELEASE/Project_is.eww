<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\application_is.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\lib_webrtc_pic.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\lib_webrtc_producer_c.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\libsrtp2.ewp</path>
    </project>
    <batchBuild />
</workspace>
