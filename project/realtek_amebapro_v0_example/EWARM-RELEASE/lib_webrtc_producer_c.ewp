# IAR project lib_webrtc_producer_c.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: __thumb2__; CONFIG_PLATFORM_8195BHP; __FPU_PRESENT; __ARM_ARCH_7M__=0; __ARM_ARCH_8M_MAIN__=1; __ARM_ARCH_8M_BASE__=0; CONFIG_BUILD_RAM=1; _NO_DEFINITIONS_IN_HEADER_FILES; __IEEE_LITTLE_ENDIAN; KVS_USE_MBEDTLS; KVS_BUILD_WITH_LWS; LWS_AMAZON_RTOS
  ICCARM.IExtraOptions: --cmse; --enum_is_int; --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\lib_amazon\iar_include; ..\..\..\component\os\freertos\freertos_v10.0.0\portable\posix\lib\include; ..\..\..\component\os\freertos\freertos_v10.0.0\portable\posix\lib\FreeRTOS-Plus-POSIX\include\portable\realtek\rtl8195; ..\..\..\component\os\freertos\freertos_v10.0.0\portable\posix\lib\FreeRTOS-Plus-POSIX\include; ..\..\..\component\os\freertos\freertos_v10.0.0\portable\posix\lib\include\private; ..\..\..\component\os\freertos\freertos_v10.0.0\include; ..\..\..\component\os\freertos; ..\..\..\component\os\freertos\freertos_v10.0.0\portable\IAR\ARM_RTL8195B; ..\..\..\component\common\api\platform; ..\..\..\component\soc\realtek\8195b\cmsis\rtl8195b-hp\include; ..\..\..\component\common\api; ..\..\..\component\common\api\platform; ..\..\..\component\common\api\network\include; ..\..\..\component\common\api\wifi; ..\..\..\lib_amazon\amazon-kinesis-video-streams-producer-c\src\include; ..\..\..\lib_amazon\amazon-kinesis-video-streams-pic\src\client\include; ..\..\..\lib_amazon\amazon-kinesis-video-streams-pic\src\common\include; ..\..\..\lib_amazon\amazon-kinesis-video-streams-pic\src\utils\include; ..\..\..\lib_amazon\amazon-kinesis-video-streams-pic\src\heap\include; ..\..\..\lib_amazon\amazon-kinesis-video-streams-pic\src\state\include; ..\..\..\lib_amazon\amazon-kinesis-video-streams-pic\src\trace\include; ..\..\..\lib_amazon\amazon-kinesis-video-streams-pic\src\view\include; ..\..\..\lib_amazon\amazon-kinesis-video-streams-pic\src\mkvgen\include; ..\..\..\component\common\network\ssl\mbedtls-2.16.4\include_; ..\..\..\component\common\network\ssl\mbedtls-2.16.6\include; ..\..\..\component\common\network\lwip\lwip_v2.0.2\src\include; ..\..\..\component\common\network\lwip\lwip_v2.0.2\src\include\lwip; ..\..\..\component\common\network\lwip\lwip_v2.0.2\port\realtek; ..\..\..\component\common\network\lwip\lwip_v2.0.2\port\realtek\freertos; ..\..\..\component\common\network\ssl\ssl_ram_map\rom; ..\..\..\component\os\freertos\freertos_v10.0.0\portable\posix\lib\include\FreeRTOS_POSIX; ..\..\..\component\os\freertos\freertos_v10.0.0\portable\posix\lib\FreeRTOS-Plus-POSIX\include\portable\realtek\rtl8195; ..\..\..\lib_amazon\libwebsockets\include; ..\..\..\lib_amazon\libwebsockets; ..\..\..\component\common\file_system\fatfs\r0.14; ..\..\..\component\common\file_system\fatfs
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  ILINK.IlinkOutputFile: lib_webrtc_producer_c.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group common
    ../../../lib_amazon/amazon-kinesis-video-streams-producer-c/src/source/Common/: Auth.c AwsV4Signer.c FileCredentialProvider.c IotCredentialProvider.c jsmn.c RequestInfo.c StaticCredentialProvider.c Util.c Version.c
  group common/lws
    ../../../lib_amazon/amazon-kinesis-video-streams-producer-c/src/source/Common/Lws/: LwsCall.c LwsIotCredentialProvider.c
  group lib_pic
    ../../../component/soc/realtek/8195b/misc/bsp/lib/common/IAR/: lib_webrtc_pic.a
