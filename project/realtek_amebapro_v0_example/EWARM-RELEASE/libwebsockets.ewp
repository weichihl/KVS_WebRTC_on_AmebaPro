# IAR project libwebsockets.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: __thumb2__; CONFIG_PLATFORM_8195BHP; __FPU_PRESENT; CONFIG_BUILD_RAM=1; __ARM_ARCH_7M__=0; __ARM_ARCH_8M_MAIN__=1; __ARM_ARCH_8M_BASE__=0; _NO_DEFINITIONS_IN_HEADER_FILES; LWS_AMAZON_RTOS
  ICCARM.IExtraOptions: --cmse; --enum_is_int; --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\lib_amazon\iar_include; ..\..\..\lib_amazon\libwebsockets; ..\..\..\lib_amazon\libwebsockets\include; ..\..\..\lib_amazon\libwebsockets\lib\core; ..\..\..\lib_amazon\libwebsockets\lib\core-net; ..\..\..\lib_amazon\libwebsockets\lib\event-libs; ..\..\..\lib_amazon\libwebsockets\lib\event-libs\poll; ..\..\..\lib_amazon\libwebsockets\lib\plat\freertos; ..\..\..\lib_amazon\libwebsockets\lib\plat\freertos\esp32; ..\..\..\lib_amazon\libwebsockets\lib\roles; ..\..\..\lib_amazon\libwebsockets\lib\roles\h1; ..\..\..\lib_amazon\libwebsockets\lib\roles\h2; ..\..\..\lib_amazon\libwebsockets\lib\roles\http; ..\..\..\lib_amazon\libwebsockets\lib\roles\ws; ..\..\..\lib_amazon\libwebsockets\lib\system\smd; ..\..\..\lib_amazon\libwebsockets\lib\tls; ..\..\..\lib_amazon\libwebsockets\lib\tls\mbedtls\wrapper\include; ..\..\..\lib_amazon\libwebsockets\lib\tls\mbedtls\wrapper\include\internal; ..\..\..\lib_amazon\libwebsockets\lib\tls\mbedtls\wrapper\include\openssl; ..\..\..\lib_amazon\libwebsockets\lib\tls\mbedtls\wrapper\include\platform; ..\..\..\component\common\network\ssl\mbedtls-2.16.4\include_; ..\..\..\component\common\network\ssl\mbedtls-2.16.6\include; ..\..\..\component\common\network\ssl\ssl_ram_map\rom; ..\..\..\component\os\freertos; ..\..\..\component\os\freertos\freertos_v10.0.0\include; ..\..\..\component\os\freertos\freertos_v10.0.0\portable\IAR\ARM_RTL8195B; ..\..\..\component\os\freertos\freertos_v10.0.0\secure; ..\..\..\component\os\os_dep\include; ..\..\..\component\common\api; ..\..\..\component\common\api\platform; ..\..\..\component\common\api\network\include; ..\..\..\component\common\api\wifi; ..\..\..\component\soc\realtek\8195b\misc\utilities\include; ..\..\..\component\soc\realtek\8195b\cmsis\cmsis-core\include; ..\..\..\component\soc\realtek\8195b\app\rtl_printf\include; ..\..\..\component\soc\realtek\8195b\cmsis\rtl8195b-hp\include; ..\..\..\component\soc\realtek\8195b\cmsis\rtl8195b-hp\lib\include; ..\..\..\component\soc\realtek\8195b\app\stdio_port; ..\..\..\component\soc\realtek\8195b\misc\utilities\include; ..\..\..\component\soc\realtek\8195b\mbed-hal\hal_ext; ..\..\..\component\soc\realtek\8195b\mbed-hal\targets\hal\rtl8195bh; ..\..\..\component\soc\realtek\8195b\fwlib\hal-rtl8195b-hp\include; ..\..\..\component\soc\realtek\8195b\fwlib\hal-rtl8195b-hp\lib\include; ..\..\..\component\soc\realtek\8195b\fwlib\hal-rtl8195b-hp\include\usb_otg; ..\..\..\component\soc\realtek\8195b\fwlib\hal-rtl8195b-hp\lib\include\usb_otg; ..\..\..\component\soc\realtek\8195b\fwlib\hal-rtl8195b-hp\lib\video\isp\include; ..\..\..\component\common\network\lwip\lwip_v2.0.2\src\include; ..\..\..\component\common\network\lwip\lwip_v2.0.2\src\include\lwip; ..\..\..\component\common\network\lwip\lwip_v2.0.2\port\realtek; ..\..\..\component\common\network\lwip\lwip_v2.0.2\port\realtek\freertos; ..\..\..\component\common\file_system\fatfs; ..\..\..\component\common\file_system\fatfs\r0.14; ..\..\..\component\os\freertos\freertos_v10.0.0\portable\posix\lib\include; ..\..\..\component\os\freertos\freertos_v10.0.0\portable\posix\lib\FreeRTOS-Plus-POSIX\include\portable\realtek\rtl8195; ..\..\..\component\os\freertos\freertos_v10.0.0\portable\posix\lib\FreeRTOS-Plus-POSIX\include; ..\..\..\component\os\freertos\freertos_v10.0.0\portable\posix\lib\include\private; ..\..\..\component\os\freertos\freertos_v10.0.0\portable\IAR\ARM_RTL8195B
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: lib_http.out
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: libwebsockets.out
  group core
    ../../../lib_amazon/libwebsockets/lib/core/: alloc.c buflist.c context.c libwebsockets.c logs.c lws_dll2.c
  group core-net
    ../../../lib_amazon/libwebsockets/lib/core-net/: adopt.c client.c close.c connect.c dummy-callback.c network.c output.c pollfd.c sequencer.c service.c sorted-usec-list.c state.c vhost.c wsi-timeout.c wsi.c
  group event-libs
    ../../../lib_amazon/libwebsockets/lib/event-libs/poll/: poll.c
  group misc
    ../../../lib_amazon/libwebsockets/lib/misc/: base64-decode.c lejp.c lws-ring.c romfs.c sha-1.c
    ../../../lib_amazon/libwebsockets/lib/misc/lwsac/: lwsac.c
  group plat
    ../../../lib_amazon/libwebsockets/lib/plat/freertos/: freertos-fds.c freertos-init.c freertos-misc.c freertos-pipe.c freertos-service.c freertos-sockets.c
  group roles/h1
    ../../../lib_amazon/libwebsockets/lib/roles/h1/: ops-h1.c
  group roles/h2
    ../../../lib_amazon/libwebsockets/lib/roles/h2/: hpack.c http2.c ops-h2.c
  group roles/http
    ../../../lib_amazon/libwebsockets/lib/roles/http/client/: client-handshake.c client-http.c
    ../../../lib_amazon/libwebsockets/lib/roles/http/: header.c parsers.c
    ../../../lib_amazon/libwebsockets/lib/roles/http/server/: ranges.c
  group roles/pipe
    ../../../lib_amazon/libwebsockets/lib/roles/pipe/: ops-pipe.c
  group roles/raw
    ../../../lib_amazon/libwebsockets/lib/roles/raw-file/: ops-raw-file.c
    ../../../lib_amazon/libwebsockets/lib/roles/raw-skt/: ops-raw-skt.c
  group roles/ws
    ../../../lib_amazon/libwebsockets/lib/roles/ws/: client-parser-ws.c client-ws.c ops-ws.c
  group system
    ../../../lib_amazon/libwebsockets/lib/system/smd/: smd.c
    ../../../lib_amazon/libwebsockets/lib/system/: system.c
  group tls
    ../../../lib_amazon/libwebsockets/lib/tls/: tls-client.c tls-network.c tls.c
  group tls/mbedtls
    ../../../lib_amazon/libwebsockets/lib/tls/mbedtls/: mbedtls-client.c mbedtls-ssl.c mbedtls-tls.c mbedtls-x509.c
  group tls/mbedtls/wrapper
    ../../../lib_amazon/libwebsockets/lib/tls/mbedtls/wrapper/library/: ssl_cert.c ssl_lib.c ssl_methods.c ssl_pkey.c ssl_stack.c ssl_x509.c
    ../../../lib_amazon/libwebsockets/lib/tls/mbedtls/wrapper/platform/: ssl_pm.c ssl_port.c
