# IAR project libusrsctp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: __thumb2__; CONFIG_PLATFORM_8195BHP; __FPU_PRESENT; CONFIG_BUILD_RAM=1; __ARM_ARCH_7M__=0; __ARM_ARCH_8M_MAIN__=1; __ARM_ARCH_8M_BASE__=0; _NO_DEFINITIONS_IN_HEADER_FILES; __Userspace__; SCTP_SIMPLE_ALLOCATOR; SCTP_PROCESS_LEVEL_LOCKS; KVS_PLAT_RTK_FREERTOS
  ICCARM.IExtraOptions: --cmse; --enum_is_int; --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\lib_amazon\libusrsctp\usrsctplib; ..\..\..\lib_amazon\libusrsctp\usrsctplib\netinet; ..\..\..\lib_amazon\libusrsctp\usrsctplib\netinet6; ..\..\..\component\os\freertos; ..\..\..\component\os\freertos\freertos_v10.0.0\include; ..\..\..\component\os\freertos\freertos_v10.0.0\portable\IAR\ARM_RTL8195B; ..\..\..\component\os\freertos\freertos_v10.0.0\secure; ..\..\..\component\os\freertos\freertos_v10.0.0\portable\posix\lib\include; ..\..\..\component\os\freertos\freertos_v10.0.0\portable\posix\lib\include\private; ..\..\..\component\os\freertos\freertos_v10.0.0\portable\posix\lib\include\FreeRTOS_POSIX; ..\..\..\component\os\freertos\freertos_v10.0.0\portable\posix\lib\FreeRTOS-Plus-POSIX\include; ..\..\..\component\os\freertos\freertos_v10.0.0\portable\posix\lib\FreeRTOS-Plus-POSIX\include\portable\realtek\rtl8195; ..\..\..\component\os\os_dep\include; ..\..\..\component\common\api; ..\..\..\component\common\api\platform; ..\..\..\component\common\api\network\include; ..\..\..\component\common\api\wifi; ..\..\..\component\soc\realtek\8195b\misc\utilities\include; ..\..\..\component\soc\realtek\8195b\cmsis\cmsis-core\include; ..\..\..\component\soc\realtek\8195b\app\rtl_printf\include; ..\..\..\component\soc\realtek\8195b\cmsis\rtl8195b-hp\include; ..\..\..\component\soc\realtek\8195b\cmsis\rtl8195b-hp\lib\include; ..\..\..\component\soc\realtek\8195b\app\stdio_port; ..\..\..\component\soc\realtek\8195b\misc\utilities\include; ..\..\..\component\soc\realtek\8195b\mbed-hal\hal_ext; ..\..\..\component\soc\realtek\8195b\mbed-hal\targets\hal\rtl8195bh; ..\..\..\component\soc\realtek\8195b\fwlib\hal-rtl8195b-hp\include; ..\..\..\component\soc\realtek\8195b\fwlib\hal-rtl8195b-hp\lib\include; ..\..\..\component\soc\realtek\8195b\fwlib\hal-rtl8195b-hp\include\usb_otg; ..\..\..\component\soc\realtek\8195b\fwlib\hal-rtl8195b-hp\lib\include\usb_otg; ..\..\..\component\soc\realtek\8195b\fwlib\hal-rtl8195b-hp\lib\video\isp\include; ..\..\..\component\common\network\lwip\lwip_v2.0.2\src\include; ..\..\..\component\common\network\lwip\lwip_v2.0.2\src\include\lwip; ..\..\..\component\common\network\lwip\lwip_v2.0.2\src\include\posix; ..\..\..\component\common\network\lwip\lwip_v2.0.2\port\realtek; ..\..\..\component\common\network\lwip\lwip_v2.0.2\port\realtek\freertos; ..\..\..\component\common\network\ssl\mbedtls-2.16.6\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: lib_http.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group (top)
    ../../../lib_amazon/libusrsctp/usrsctplib/: user_environment.c user_mbuf.c user_recv_thread.c user_socket.c
  group netinet
    ../../../lib_amazon/libusrsctp/usrsctplib/netinet/: sctp_asconf.c sctp_auth.c sctp_bsd_addr.c sctp_callout.c sctp_cc_functions.c sctp_crc32.c sctp_indata.c sctp_input.c sctp_output.c sctp_pcb.c sctp_peeloff.c sctp_sha1.c sctp_ss_functions.c sctp_sysctl.c sctp_timer.c sctp_userspace.c sctp_usrreq.c sctputil.c
  group netinet6
    ../../../lib_amazon/libusrsctp/usrsctplib/netinet6/: sctp6_usrreq.c
