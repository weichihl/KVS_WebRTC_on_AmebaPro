# IAR project lib_opusfile.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: __thumb2__; CONFIG_PLATFORM_8195BHP; __FPU_PRESENT; __ARM_ARCH_7M__=0; __ARM_ARCH_8M_MAIN__=1; __ARM_ARCH_8M_BASE__=0; CONFIG_BUILD_RAM=1; _NO_DEFINITIONS_IN_HEADER_FILES; DISABLE_FLOAT_API; OP_FIXED_POINT
  ICCARM.IExtraOptions: --cmse; --enum_is_int; --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\lib_amazon\iar_include; ..\..\..\component\common\api; ..\..\..\component\common\api\platform; ..\..\..\component\soc\realtek\8195b\cmsis\rtl8195b-hp\include; ..\..\..\component\common\audio\opus-1.3.1\include; ..\..\..\component\common\audio\libogg-1.3.3\include; ..\..\..\component\common\audio\opusfile-0.11\src; ..\..\..\component\common\audio\opusfile-0.11\include; ..\..\..\component\common\audio\opusfile-0.11\\win32
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  ILINK.IlinkOutputFile: lib_opusfile.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group (top)
    ../../../component/common/audio/opusfile-0.11/src/: info.c internal.c opusfile.c stream.c wincerts.c
