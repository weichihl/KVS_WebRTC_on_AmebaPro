# IAR project lib_amazon_LTS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: __thumb2__; CONFIG_PLATFORM_8195B; CONFIG_PLATFORM_8195BHP; __FPU_PRESENT; __ARM_ARCH_7M__=0; __ARM_ARCH_8M_MAIN__=1; __ARM_ARCH_8M_BASE__=0; CONFIG_BUILD_RAM=1; _NO_DEFINITIONS_IN_HEADER_FILES; ARM_MATH_CM7; V8M_STKOVF; CONFIG_FATFS_WRAPPER=1
  ICCARM.IExtraOptions: --cmse; --enum_is_int; --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\component\soc\realtek\8195b\cmsis\rtl8195b-hp\include; ..\..\..\component\common\drivers\sdio\realtek\sdio_host\src; ..\..\..\component\soc\realtek\8195b\cmsis\cmsis-core\include; ..\..\..\component\soc\realtek\8195b\cmsis\rtl8195b-hp\lib\include; ..\..\..\component\soc\realtek\8195b\fwlib\hal-rtl8195b-hp\include; ..\..\..\component\soc\realtek\8195b\fwlib\hal-rtl8195b-hp\lib\include; ..\..\..\component\soc\realtek\8195b\app\rtl_printf\include; ..\..\..\component\soc\realtek\8195b\app\shell; ..\..\..\component\soc\realtek\8195b\app\stdio_port; ..\..\..\component\os\freertos; ..\..\..\component\os\freertos\freertos_v10.0.0\include; ..\..\..\component\os\freertos\freertos_v10.0.0\portable\IAR\ARM_RTL8195B; ..\..\..\component\os\freertos\freertos_v10.0.0\secure; ..\..\..\component\os\os_dep\include; ..\..\..\component\soc\realtek\8195b\misc\utilities\include; ..\..\..\component\soc\realtek\8195b\misc\platform; ..\..\..\component\soc\realtek\8195b\fwlib\hal-rtl8195b-hp\include\usb_otg; ..\..\..\component\common\api; ..\..\..\component\common\api\at_cmd; ..\..\..\component\common\api\platform; ..\..\..\component\common\api\wifi; ..\..\..\component\common\api\network\include; ..\..\..\component\common\network\lwip\lwip_v2.0.2\src\include; ..\..\..\component\common\network\lwip\lwip_v2.0.2\src\include\lwip; ..\..\..\component\common\network\lwip\lwip_v2.0.2\port\realtek; ..\..\..\component\common\network\lwip\lwip_v2.0.2\port\realtek\freertos; ..\..\..\component\common\network; ..\..\..\component\common\drivers\wlan\realtek\include; ..\..\..\component\common\drivers\wlan\realtek\src\osdep; ..\..\..\component\soc\realtek\8195b\mbed-hal\hal; ..\..\..\component\soc\realtek\8195b\mbed-hal\hal_ext; ..\..\..\component\soc\realtek\8195b\mbed-drivers\include; ..\..\..\component\soc\realtek\8195b\cmsis\cmsis-dsp\include; ..\..\..\component\soc\realtek\8195b\mbed-hal\targets\hal\rtl8195bh; ..\..\..\component\common\drivers\sdio\realtek\sdio_host\inc; ..\..\..\component\soc\realtek\8195b\cmsis\cmsis-core\include; ..\..\..\component\soc\realtek\8195a\fwlib\rtl8195a; ..\..\..\component\soc\realtek\8195a\misc\os; ..\..\..\component\soc\realtek\8195b\mbed-hal\targets\hal\rtl8195bh; ..\..\..\component\common\api\wifi\rtw_wpa_supplicant\src; ..\..\..\component\soc\realtek\8711b\swlib\std_lib\include; ..\..\..\component\common\network\ssl\mbedtls-2.16.6\include; ..\..\..\component\common\network\ssl\ssl_ram_map\rom; ..\..\..\component\common\drivers\i2s; ..\..\..\component\common\utilities; ..\..\..\component\common\application; ..\..\..\component\soc\realtek\8195b\app\xmodem\rom; ..\..\..\component\common\mbed\hal; ..\..\..\component\common\mbed\hal_ext; ..\..\..\component\common\mbed\targets\hal\rtl8195b\hal\rtl8195bh; ..\..\..\component\soc\realtek\8195b\misc\driver; ..\..\..\component\os\freertos\freertos_v10.0.0\portable\posix\lib\include; ..\..\..\component\os\freertos\freertos_v10.0.0\portable\posix\lib\FreeRTOS-Plus-POSIX\include\portable\realtek\rtl8195; ..\..\..\component\os\freertos\freertos_v10.0.0\portable\posix\lib\FreeRTOS-Plus-POSIX\include; ..\..\..\component\os\freertos\freertos_v10.0.0\portable\posix\lib\include\private; ..\..\..\lib_amazon\amazon-freertos-202012.00\libraries\freertos_plus\standard\utils\include; ..\..\..\lib_amazon\amazon-freertos-202012.00\libraries\logging\include; ..\..\..\lib_amazon\amazon-freertos-202012.00\libraries\abstractions\wifi\include; ..\..\..\lib_amazon\amazon-freertos-202012.00\libraries\3rdparty\unity\src; ..\..\..\lib_amazon\amazon-freertos-202012.00\libraries\3rdparty\unity\extras\fixture\src; ..\..\..\lib_amazon\amazon-freertos-202012.00\libraries\c_sdk\standard\common\include; ..\..\..\lib_amazon\amazon-freertos-202012.00\libraries\abstractions\platform\freertos\include; ..\..\..\lib_amazon\amazon-freertos-202012.00\libraries\abstractions\platform\include; ..\..\..\lib_amazon\amazon-freertos-202012.00\libraries\abstractions\secure_sockets\include; ..\..\..\lib_amazon\amazon-freertos-202012.00\libraries\c_sdk\standard\common\include\private; ..\..\..\lib_amazon\amazon-freertos-202012.00\libraries\abstractions\pkcs11\corePKCS11\source\include; ..\..\..\lib_amazon\amazon-freertos-202012.00\libraries\abstractions\pkcs11\corePKCS11\source\dependency\3rdparty\pkcs11; ..\..\..\lib_amazon\amazon-freertos-202012.00\libraries\c_sdk\standard\common\include\private; ..\..\..\lib_amazon\amazon-freertos-202012.00\libraries\c_sdk\standard\common\include\private; ..\..\..\lib_amazon\amazon-freertos-202012.00\libraries\abstractions\backoff_algorithm\source\include; ..\..\..\lib_amazon\amazon-freertos-202012.00\libraries\coreHTTP\source\include; ..\..\..\lib_amazon\amazon-freertos-202012.00\libraries\coreHTTP\source\interface; ..\..\..\lib_amazon\amazon-freertos-202012.00\libraries\abstractions\transport\secure_sockets; ..\..\..\lib_amazon\amazon-freertos-202012.00\libraries\coreMQTT\source\include; ..\..\..\lib_amazon\amazon-freertos-202012.00\libraries\3rdparty\jsmn; ..\..\..\lib_amazon\amazon-freertos-202012.00\libraries\freertos_plus\aws\ota\include; ..\..\..\lib_amazon\amazon-freertos-202012.00\libraries\3rdparty\mbedtls_utils; ..\..\..\lib_amazon\amazon-freertos-202012.00\libraries\3rdparty\mbedtls_config______; ..\..\..\lib_amazon\amazon-freertos-202012.00\libraries\3rdparty\mbedtls\include______; ..\..\..\lib_amazon\amazon-freertos-202012.00\libraries\freertos_plus\standard\crypto\include; ..\..\..\lib_amazon\amazon-freertos-202012.00\demos\dev_mode_key_provisioning\include; ..\..\..\lib_amazon\amazon-freertos-202012.00\libraries\c_sdk\aws\defender\include; ..\..\..\lib_amazon\amazon-freertos-202012.00\libraries\c_sdk\standard\mqtt\include; ..\..\..\lib_amazon\amazon-freertos-202012.00\libraries\c_sdk\standard\serializer\include; ..\..\..\lib_amazon\amazon-freertos-202012.00\libraries\c_sdk\aws\shadow\include; ..\..\..\lib_amazon\amazon-freertos-202012.00\libraries\c_sdk\standard\mqtt\test\access; ..\..\..\lib_amazon\amazon-freertos-202012.00\libraries\coreHTTP\source\dependency\3rdparty\http_parser; ..\..\..\lib_amazon\amazon-freertos-202012.00\libraries\c_sdk\standard\https\include; ..\..\..\lib_amazon\amazon-freertos-202012.00\libraries\c_sdk\standard\https\test\access; ..\..\..\lib_amazon\amazon-freertos-202012.00\libraries\c_sdk\standard\mqtt\src; ..\..\..\lib_amazon\amazon-freertos-202012.00\libraries\c_sdk\standard\mqtt\test\mock; ..\..\..\lib_amazon\amazon-freertos-202012.00\libraries\3rdparty\tinycbor\src; ..\..\..\lib_amazon\amazon-freertos-202012.00\libraries\freertos_plus\aws\ota\src; ..\..\..\lib_amazon\amazon-freertos-202012.00\libraries\freertos_plus\standard\tls\include; ..\..\..\common\application\amazon\amazon-freertos-202012.00\demos\common\pkcs11_helpers; ..\..\..\lib_amazon\amazon-freertos-202012.00\demos\common\pkcs11_helpers; ..\..\..\lib_amazon\amazon-freertos-202012.00\demos\include; ..\..\..\lib_amazon\amazon-freertos-202012.00\demos\network_manager; ..\..\..\lib_amazon\amazon-freertos-202012.00\vendors\realtek\boards\amebaPro\aws_demos\config_files; ..\..\..\lib_amazon\amazon-freertos-202012.00\demos\common\http_demo_helpers; ..\..\..\lib_amazon\amazon-freertos-202012.00\libraries\device_shadow_for_aws\source\include; ..\..\..\lib_amazon\amazon-freertos-202012.00\libraries\coreJSON\source\include; ..\..\..\lib_amazon\amazon-freertos-202012.00\demos\common\mqtt_demo_helpers; ..\..\..\lib_amazon\amazon-freertos-202012.00\libraries\freertos_plus\aws\ota\test
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  ILINK.IlinkOutputFile: lib_amazon_LTS.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  group libraries/3rdparty/jsmn
    ../../../lib_amazon/amazon-freertos-202012.00/libraries/3rdparty/jsmn/: jsmn.c
  group libraries/3rdparty/mbedtls/library
    ../../../lib_amazon/amazon-freertos-202012.00/libraries/3rdparty/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group libraries/3rdparty/mbedtls_utils
    ../../../lib_amazon/amazon-freertos-202012.00/libraries/3rdparty/mbedtls_utils/: mbedtls_error.c mbedtls_utils.c
  group libraries/3rdparty/tinycbor
    ../../../lib_amazon/amazon-freertos-202012.00/libraries/3rdparty/tinycbor/src/: cborencoder.c cborencoder_close_container_checked.c cborerrorstrings.c cborparser.c cborparser_dup_string.c cborpretty.c cborpretty_stdio.c cborvalidation.c
  group libraries/3rdparty/unity
    ../../../lib_amazon/amazon-freertos-202012.00/libraries/3rdparty/unity/src/: unity.c
    ../../../lib_amazon/amazon-freertos-202012.00/libraries/3rdparty/unity/extras/fixture/src/: unity_fixture.c
  group libraries/abstractions/backoff_algorithm
    ../../../lib_amazon/amazon-freertos-202012.00/libraries/abstractions/backoff_algorithm/source/: backoff_algorithm.c
  group libraries/abstractions/pkcs11/corePKCS11
    ../../../lib_amazon/amazon-freertos-202012.00/libraries/abstractions/pkcs11/corePKCS11/source/: core_pkcs11.c core_pki_utils.c
  group libraries/abstractions/pkcs11/corePKCS11/portable/mbedtls
    ../../../lib_amazon/amazon-freertos-202012.00/libraries/abstractions/pkcs11/corePKCS11/source/portable/mbedtls/: core_pkcs11_mbedtls.c
  group libraries/abstractions/platform/freertos
    ../../../lib_amazon/amazon-freertos-202012.00/libraries/abstractions/platform/freertos/: iot_clock_freertos.c iot_metrics.c iot_network_freertos.c iot_threads_freertos.c
  group libraries/abstractions/transport/secure_sockets
    ../../../lib_amazon/amazon-freertos-202012.00/libraries/abstractions/transport/secure_sockets/: transport_secure_sockets.c
  group libraries/c_sdk/aws/defender
    ../../../lib_amazon/amazon-freertos-202012.00/libraries/c_sdk/aws/defender/src/: aws_iot_defender_api.c aws_iot_defender_collector.c aws_iot_defender_mqtt.c aws_iot_defender_v1.c
  group libraries/c_sdk/aws/shadow
    ../../../lib_amazon/amazon-freertos-202012.00/libraries/c_sdk/aws/shadow/src/: aws_iot_shadow_api.c aws_iot_shadow_operation.c aws_iot_shadow_parser.c aws_iot_shadow_static_memory.c aws_iot_shadow_subscription.c aws_shadow.c
  group libraries/c_sdk/standard/common
    ../../../lib_amazon/amazon-freertos-202012.00/libraries/c_sdk/standard/common/: iot_device_metrics.c iot_init.c iot_static_memory_common.c
  group libraries/c_sdk/standard/common/taskpool
    ../../../lib_amazon/amazon-freertos-202012.00/libraries/c_sdk/standard/common/taskpool/: iot_taskpool.c iot_taskpool_static_memory.c
  group libraries/c_sdk/standard/https
    ../../../lib_amazon/amazon-freertos-202012.00/libraries/c_sdk/standard/https/src/: iot_https_client.c iot_https_utils.c
  group libraries/c_sdk/standard/mqtt
    ../../../lib_amazon/amazon-freertos-202012.00/libraries/c_sdk/standard/mqtt/src/: iot_mqtt_agent.c iot_mqtt_api.c iot_mqtt_context_connection.c iot_mqtt_managed_function_wrapper.c iot_mqtt_mutex_wrapper.c iot_mqtt_network.c iot_mqtt_operation.c iot_mqtt_publish_duplicates.c iot_mqtt_serializer_deserializer_wrapper.c iot_mqtt_static_memory.c iot_mqtt_subscription.c iot_mqtt_subscription_container.c iot_mqtt_validate.c
  group libraries/coreHTTP
    ../../../lib_amazon/amazon-freertos-202012.00/libraries/coreHTTP/source/: core_http_client.c
  group libraries/coreHTTP/http_parser
    ../../../lib_amazon/amazon-freertos-202012.00/libraries/coreHTTP/source/dependency/3rdparty/http_parser/: http_parser.c
  group libraries/coreJSON
    ../../../lib_amazon/amazon-freertos-202012.00/libraries/coreJSON/source/: core_json.c
  group libraries/coreMQTT
    ../../../lib_amazon/amazon-freertos-202012.00/libraries/coreMQTT/source/: core_mqtt.c core_mqtt_serializer.c core_mqtt_state.c
  group libraries/device_shadow_for_aws
    ../../../lib_amazon/amazon-freertos-202012.00/libraries/device_shadow_for_aws/source/: shadow.c
  group libraries/freertos_plus/aws
    ../../../lib_amazon/amazon-freertos-202012.00/libraries/freertos_plus/aws/ota/src/: aws_iot_ota_agent.c aws_iot_ota_interface.c
    ../../../lib_amazon/amazon-freertos-202012.00/libraries/freertos_plus/aws/ota/src/mqtt/: aws_iot_ota_cbor.c aws_iot_ota_mqtt.c
  group libraries/freertos_plus/standard/crypto
    ../../../lib_amazon/amazon-freertos-202012.00/libraries/freertos_plus/standard/crypto/src/: iot_crypto.c
  group libraries/freertos_plus/standard/tls
    ../../../lib_amazon/amazon-freertos-202012.00/libraries/freertos_plus/standard/tls/src/: iot_tls.c
  group libraries/freertos_plus/standard/utils
    ../../../lib_amazon/amazon-freertos-202012.00/libraries/freertos_plus/standard/utils/src/: iot_system_init.c
  group libraries/logging
    ../../../lib_amazon/amazon-freertos-202012.00/libraries/logging/: iot_logging.c iot_logging_task_dynamic_buffers.c
  group vendor/port
    ../../../lib_amazon/amazon-freertos-202012.00/vendors/realtek/boards/amebaPro/ports/ota/: aws_ota_amebapro.c aws_ota_pal.c
    ../../../lib_amazon/amazon-freertos-202012.00/vendors/realtek/boards/amebaPro/ports/pkcs11/: core_pkcs11_pal.c
    ../../../lib_amazon/amazon-freertos-202012.00/vendors/realtek/boards/amebaPro/ports/secure_sockets/: iot_secure_sockets.c
    ../../../lib_amazon/amazon-freertos-202012.00/vendors/realtek/boards/amebaPro/ports/wifi/: iot_wifi.c
